#define PERL_constant_NOTFOUND	1
#define PERL_constant_NOTDEF	2
#define PERL_constant_ISIV	3
#define PERL_constant_ISNO	4
#define PERL_constant_ISNV	5
#define PERL_constant_ISPV	6
#define PERL_constant_ISPVN	7
#define PERL_constant_ISSV	8
#define PERL_constant_ISUNDEF	9
#define PERL_constant_ISUV	10
#define PERL_constant_ISYES	11

#ifndef NVTYPE
typedef double NV; /* 5.6 and later define NVTYPE, and typedef NV to it.  */
#endif
#ifndef aTHX_
#define aTHX_ /* 5.6 or later define this for threading support.  */
#endif
#ifndef pTHX_
#define pTHX_ /* 5.6 or later define this for threading support.  */
#endif

static int
constant (pTHX_ const char *name, STRLEN len, IV *iv_return) {
  /* Initially switch on the length of the name.  */
  /* When generated this function returned values for the list of names given
     in this section of perl code.  Rather than manually editing these functions
     to add or remove constants, which would result in this comment and section
     of code becoming inaccurate, we recommend that you edit this section of
     code, and use it to regenerate a new set of constant functions which you
     then use to replace the originals.

     Regenerate these constant functions by feeding this entire source file to
     perl -x

#!/usr/local/jperl/5.12.5/bin/perl5.12.5 -w
use ExtUtils::Constant qw (constant_types C_constant XS_constant);

my $types = {map {($_, 1)} qw(IV)};
my @names = (qw(REG_EXTENDED REG_ICASE REG_NEWLINE REG_NOTBOL REG_NOTEOL));

print constant_types(), "\n"; # macro defs
foreach (C_constant ("POSIX::Regex", 'constant', 'IV', $types, undef, 3, @names) ) {
    print $_, "\n"; # C constant subs
}
print "\n#### XS Section:\n";
print XS_constant ("POSIX::Regex", $types);
__END__
   */

  switch (len) {
  case 9:
    if (memEQ(name, "REG_ICASE", 9)) {
#ifdef REG_ICASE
      *iv_return = REG_ICASE;
      return PERL_constant_ISIV;
#else
      return PERL_constant_NOTDEF;
#endif
    }
    break;
  case 10:
    /* Names all of length 10.  */
    /* REG_NOTBOL REG_NOTEOL */
    /* Offset 7 gives the best switch position.  */
    switch (name[7]) {
    case 'B':
      if (memEQ(name, "REG_NOTBOL", 10)) {
      /*                      ^         */
#ifdef REG_NOTBOL
        *iv_return = REG_NOTBOL;
        return PERL_constant_ISIV;
#else
        return PERL_constant_NOTDEF;
#endif
      }
      break;
    case 'E':
      if (memEQ(name, "REG_NOTEOL", 10)) {
      /*                      ^         */
#ifdef REG_NOTEOL
        *iv_return = REG_NOTEOL;
        return PERL_constant_ISIV;
#else
        return PERL_constant_NOTDEF;
#endif
      }
      break;
    }
    break;
  case 11:
    if (memEQ(name, "REG_NEWLINE", 11)) {
#ifdef REG_NEWLINE
      *iv_return = REG_NEWLINE;
      return PERL_constant_ISIV;
#else
      return PERL_constant_NOTDEF;
#endif
    }
    break;
  case 12:
    if (memEQ(name, "REG_EXTENDED", 12)) {
#ifdef REG_EXTENDED
      *iv_return = REG_EXTENDED;
      return PERL_constant_ISIV;
#else
      return PERL_constant_NOTDEF;
#endif
    }
    break;
  }
  return PERL_constant_NOTFOUND;
}

